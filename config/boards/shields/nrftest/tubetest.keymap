#include <behaviors.dtsi>
#include <dt-bindings/zmk/keys.h>


/ {
    keymap {
        compatible = "zmk,keymap";

        defautlt_layer {
            bindings = < &kp kp_A >;
        }
    };
}